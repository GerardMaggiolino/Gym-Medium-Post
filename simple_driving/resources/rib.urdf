Commit message: jhdfgfghj

File: simple_driving/resources/rib.urdf (robot description, URDF)
Before this commit: robot rib, 1 links, 0 joints
Links:
- link ridge: geometry collision box size=0.06 20 0.06; visual box size=0.06 20 0.06
